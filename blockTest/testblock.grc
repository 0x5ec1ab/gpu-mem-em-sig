options:
  parameters:
    generate_options: qt_gui
    id: BlockTest1
    output_language: python
    title: BlockTest1
  states: {}

blocks:
- name: fftSize
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: freqCenter
  id: variable
  parameters:
    value: '810000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fftSize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftSize
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftSize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftSize)
  states: {}
- name: gpu_em_blocks_ssc_mask_0
  id: gpu_em_blocks_ssc_mask
  parameters:
    fShiftLimit: '5000'
    fftSize: fftSize
    freqCenter: freqCenter
    sampRate: samp_rate
    sscFBgn: '805832293'
    sscFEnd: '810046912'
    sscFStep: '32926.71'
    thresholdMatch: '10'
  states: {}
- name: gpu_em_blocks_vector_diff_1
  id: gpu_em_blocks_vector_diff
  parameters:
    dStep: '1'
    vLen: fftSize
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"matchFlag"'
    type: short
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"matchOffset"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '5000'
    srate: samp_rate/fftSize
    type: float
    ymax: '0.1'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: fftSize
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freqCenter
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', gpu_em_blocks_vector_diff_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [gpu_em_blocks_ssc_mask_0, '0', qtgui_time_sink_x_0, '0']
- [gpu_em_blocks_ssc_mask_0, '1', qtgui_number_sink_0, '0']
- [gpu_em_blocks_ssc_mask_0, '2', qtgui_number_sink_1, '0']
- [gpu_em_blocks_vector_diff_1, '0', gpu_em_blocks_ssc_mask_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
